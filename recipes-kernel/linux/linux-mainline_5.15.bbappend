# device trees for STM32MP15x support
SRC_URI += "\
    file://git/arch/arm/boot/dts/stm32mp15xa.dtsi\
    file://git/arch/arm/boot/dts/stm32mp15-m4-srm.dtsi\
    file://git/include/dt-bindings/pinctrl/stm32-pinfunc-2.h\
"

